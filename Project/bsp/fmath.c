/*******************************************************************************************************************/
/***Includes***/
//{
#include "fmath.h"
#include "zf_common_headfile.h"
#include "bsp.h"
//}
/*******************************************************************************************************************/
/***To Extern Functions***/
//{

//------------------------------------------------------------------------------------------------------------------
// @brief       快速平方根算法
// @param       number 所需要转换的值
// @return      float
//------------------------------------------------------------------------------------------------------------------
float My_sqrt(float number)
{
    long i;
    float x, y;
    const float f = 1.5F;
    float my_sqrt_reciprocal;

    x = number * 0.5F;
    y = number;
    i = * ( long * ) &y;
    i = 0x5f3759df - ( i >> 1 );

    y = * ( float * ) &i;
    y = y * ( f - ( x * y * y ) );
    y = y * ( f - ( x * y * y ) );

    my_sqrt_reciprocal = y;

    return number * my_sqrt_reciprocal;
}
//------------------------------------------------------------------------------------------------------------------
// @brief       牛顿迭代法快速计算 1.0/sqrt(x)逆平方根
// @param       x         所需要转换的值
// @return     float
//------------------------------------------------------------------------------------------------------------------
float InvSqrt(float x)
{
    float xhalf = 0.5f * x;
    int i = * (int* ) & x;  // get bits for floating VALUE
    i = 0x5f375a86- (i>>1); // gives initial guess y0
    x = * (float* )&i;      // convert bits BACK to float
    x = x * (1.5f - xhalf * x * x); // Newton step, repeating increases accuracy
    return x;
}
//------------------------------------------------------------------------------------------------------------------
// @brief       获取绝对值
// @param       n 所需要转换的值
// @return      float
//------------------------------------------------------------------------------------------------------------------
float ABS(float n)
{
  if(n>0||n==0)
  {     
    return n;
  }
  else 
    return -n;
}
//------------------------------------------------------------------------------------------------------------------
// @brief       求数值的符号+/-
// @param       x 所需要转换的值
// @return      float
//------------------------------------------------------------------------------------------------------------------
float SIGN(float x)
{ 
  float answer;
  if(x==0)
  {
    answer = 0;
  }
  else if(x>0)
  {
    answer = 1;
  }
  else
  {
    answer = -1;
  }
  return answer;
}
//------------------------------------------------------------------------------------------------------------------
// @brief       二元归一化
// @param       x 所需要转换的值
// @param       y 所需要转换的值
// @return      float
//------------------------------------------------------------------------------------------------------------------
float normalization(float x,float y,float base,int mode)
{
  float sqare_sum = 0;
  float answer = 0;
  sqare_sum = sqrt((x * x) + (y * y));
  switch(mode)
  {
    case(0):{answer =(sqare_sum<=base)?(x):((base/sqare_sum) * x);break;}
    case(1):{answer =(sqare_sum<=base)?(y):((base/sqare_sum) * y);break;}
  }
  return answer;
}
/*******************************************************************************************************************/
//}