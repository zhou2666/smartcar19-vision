/*
 * situation.c
 *
 * Created on: 2023年12月6日
 *
 * 
 */
#include "situation.h"
#include "define.h"
#include "fmath.h"
   
extern struct MID Mid_line[100]; //中线结构体

float Mid_add = 0.0;            //中线误差
float Mid_add_last = 0.0; 
float Mid_add_sum=0.0;
////双边权重靠前，单边权重靠后
//float Add_Weight[100] = {     //双边巡线权重表，0~100对应从近处到远处，速度越快权重越靠下
//        1,1,1,1,1,1,1,1,1,1,
//
//        2,2,2,2,2,2,2,2,2,2,
//
//        3,3,3,3,3,3,3,3,3,3,
//
//        4,4,4,4,4,4,4,4,4,4,
//
//        6,6,6,6,6,7,7,7,7,7,
//
//        7,7,7,7,7,6,6,6,6,6,
//
//        7,7,7,7,7,6,6,6,6,6,
//
//        6,6,6,6,6,5,5,5,5,5,
//
//        5,5,5,5,5,4,4,4,4,4,
//
//        4,4,4,4,4,4,4,4,4,4,
//};//中线每个点的权重权重,从下往上,速度越快权重越靠上
//float Add_Weight[100] = {       //双边巡线权重表，0~100对应从近处到远处，速度越快权重越靠下
//        1,1,1,1,1,1,1,1,1,1,
//
//        3,3,3,3,3,3,3,3,3,3,
//
//        4,4,4,4,4,4,4,4,4,4,
//
//        9,9,9,9,9,10,10,10,10,10,
//
//        9,9,9,9,9,10,10,10,10,10,
//
//        10,10,10,10,10,9,9,9,9,9,
//        10,10,10,10,10,9,9,9,9,9,
//        8,8,8,8,8,7,7,7,7,7,
//
//        5,5,5,5,5,5,5,5,5,5,
//
//        4,4,4,4,4,4,4,4,4,4,
//
//    //    3,3,3,3,3,3,3,3,3,3,
//
//};//中线每个点的权重权重,从下往上,速度越快权重越靠上

//float Add_Weight[100] = 
//{       //双边巡线权重表，0~100对应从近处到远处，速度越快权重越靠下
//        1,1,1,1,1,1,1,1,1,1,
//
//        3,3,3,3,3,3,3,3,3,3,
//
//        5,5,5,5,5,7,7,7,7,7,
//
//        7,7,7,7,7,8,8,8,8,8,
//
//        8,8,8,8,8,7,7,7,7,7,
//        
//        6,6,6,6,6,5,5,5,5,5,
//        
//        4,4,4,4,4,4,4,4,4,4,
//
//        2,2,2,2,2,2,2,2,2,2,
//
//        1,1,1,1,1,1,1,1,1,1,
//
//    //    3,3,3,3,3,3,3,3,3,3,
//
//};//中线每个点的权重权重,从下往上,速度越快权重越靠上
float Add_Weight[100] = 
{       //双边巡线权重表，0~100对应从近处到远处，速度越快权重越靠下
        1,1,1,1,1,1,1,1,1,1,

        3,3,3,3,3,5,5,5,5,5,

        5,5,5,5,5,7,7,7,7,7,

        7,7,7,7,7,8,8,8,8,8,

        8,8,8,8,8,7,7,7,7,7,
        
        6,6,6,6,6,5,5,5,5,5,
        
        4,4,4,4,4,4,4,4,4,4,

        2,2,2,2,2,2,2,2,2,2,

        1,1,1,1,1,1,1,1,1,1,

    //    3,3,3,3,3,3,3,3,3,3,

};//中线每个点的权重权重,从下往上,速度越快权重越靠上

//float Add_Weight[100] = 
//{       //双边巡线权重表，0~100对应从近处到远处，速度越快权重越靠下
//        3,3,3,3,3,3,3,3,3,3,
//
//        5,5,5,5,5,5,5,5,5,5,
//
//        5,5,5,5,5,7,7,7,7,7,
//
//        7,7,7,7,7,8,8,8,8,8,
//
//        8,8,8,8,8,7,7,7,7,7,
//        
//        6,6,6,6,6,5,5,5,5,5,
//        
//        4,4,4,4,4,4,4,4,4,4,
//
//        2,2,2,2,2,2,2,2,2,2,
//
//        1,1,1,1,1,1,1,1,1,1,
//
//    //    3,3,3,3,3,3,3,3,3,3,
//
//};//中线每个点的权重权重
float Add_Weight_S[100] = {       //单边巡线权重表，0~100对应从近处到远处，速度越快权重越靠下

        5,5,5,5,5,6,6,6,6,6,

        6,6,6,6,6,7,7,7,7,7,

        7,7,7,7,7,6,6,6,6,6,

        6,6,6,6,6,5,5,5,5,5,

        3,3,3,3,3,3,3,3,3,3,

        3,3,3,3,3,3,3,3,3,3,

        2,2,2,2,2,2,2,2,2,2,

        2,2,2,2,2,1,1,1,1,1,

        1,1,1,1,1,1,1,1,1,1,

        1,1,1,1,1,1,1,1,1,1,
};//中线每个点的权重权重,从下往上,速度越快权重越靠上
/*--------------------------------------------------------------------------
* 【函数功能】：获取中线偏差
* 【参    数】：
* 【返 回 值】：
*--------------------------------------------------------------------------*/
void get_mid_bias()
{
    float Midline_weight_sum = 0,Weight_sum = 0;
    Mid_add = 0;
    float k = 100.0 / (Mid_line_count*1.0);
    if(Left_findflag && Right_findflag)
    {
      for (int i = 0; i < Mid_line_count; i ++)
      {
       Midline_weight_sum += Mid_line[i].col*Add_Weight[(uint8)(k * i)];
       Weight_sum += Add_Weight[(uint8)(k * i)];
      }
    }
    else if(Left_findflag || Right_findflag)
    {
       for (int i = 0; i < Mid_line_count; i ++)
        {
         Midline_weight_sum += Mid_line[i].col*Add_Weight_S[(uint8)(k * i)];
         Weight_sum += Add_Weight_S[(uint8)(k * i)];
        }
    }
    if(Weight_sum)
    {
      Mid_add = ((Midline_weight_sum/Weight_sum)-(IMAGEW/2-1));//偏差  
    }


}
